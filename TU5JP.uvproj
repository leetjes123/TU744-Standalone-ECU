# Keil uVision project TU5JP.uvproj, settings and files
target TU5JP Development (outputs inhibited) (166/167)
  device: C167SR-LM Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xE000-0xE7FF) CLOCK(20000000) MOD167
  output: TU5JP +hex
  group Control core
    ./src/: acceleration.c auxiliary.c calibration.c diagnostic_monitors.c engine_state.c faults.c fuel.c iac.c iac_hold.c idle.c knock.c lambda.c math.c oem_adc.c oem_cadence.c oem_coolant.c oem_diagnostics.c oem_digital.c oem_dtc.c oem_dtc_config.c oem_dtc_records.c oem_history.c oem_history_codec.c oem_history_owner.c oem_ignition.c oem_inputs.c oem_mil.c oem_readiness.c oem_rotation.c oem_runtime.c oem_timing.c oem_voltage.c oem_vss.c oem_vss_input.c power.c protocol.c rotation.c runtime.c safety.c sensors.c storage.c vehicle.c wideband.c
  group C167 board
    ./target/c167/: board.c capture.c engine_outputs.c flash_cal.c fw_update.c knock_hw.c main.c ssc.c FLASHWORKER.A66 FWUPDATE.A66 START167.A66 TRAPS.A66
